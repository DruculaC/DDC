/*---------------------------------------------------
	Delay.c (v1.00)
	
	Delay functions
---------------------------------------------------*/	

#include "main.h"
#include "port.h"

#include "Delay.h"

/*---------------------------------------------------
	Delay()
	延迟程序
--------------------------------------------------*/

void Delay(unsigned int n)
{
	unsigned int x;
	while(n--)
	{
		x=5000;
		while(x--);
	}
}

/*---------------------------------------------------
	Delay3()
	延迟程序
--------------------------------------------------*/

void Delay3(unsigned int t)
{
	tWord i;
	tByte j;
	for(i=0;i<t;i++)		
	for(j=0;j<21;j++);
}

/*---------------------------------------------------
	Delay4()
	延迟程序
--------------------------------------------------*/

void Delay4(tWord t)
{
	tWord i;
	tByte j;
	for(i=0;i<t;i++)		
//	for(j=0;j<34;j++);
	for(j=0;j<26;j++);
}
	
/*--------------------------------------------------
	delay_ms()
	
	延迟约为1ms的子程序
----------------------------------------------------*/

void delay_ms(tWord count)
{
	tWord i, j;
	for(i=0;i<count;i++)
	{
		for(j=0;j<100;j++);
	}
}

/*--------------------------------------------------
	delay_us()
	
	延迟约为1us的子程序
----------------------------------------------------*/

void delay_us(tWord count1)
	{
	tWord i;
	tByte j;
	for(i=0;i<count1;i++)
		{
		for(j=0;j<4;j++);
		}
	}

/*----------------------------------------------------
	magnet_delay()
	电磁铁的延迟程序，要在里面加入对过流的判断
-----------------------------------------------------*/
void magnet_delay(void)
	{
	tByte i;
	tWord j;                                                                                                        
	for(i = 0; i < 50; i++)
		{
		for(j = 0; j< 8000; j++);
		}
	for(i = 0; i < 50; i++)
		{
		if(magnet_overcurrent == 1)
			{
			for(j = 0; j< 18000; j++);
			}
		}

	}
/*---------------------------------------------------
	end of file
----------------------------------------------------*/
